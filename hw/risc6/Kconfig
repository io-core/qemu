## hw/risc6/Kconfig
```kconfig
config RISC6_FPGA
    bool
    select RISC6
    select SERIAL
    select RISC6_TIMER
    

config RISC6
    bool
```
